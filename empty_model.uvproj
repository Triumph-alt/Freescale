# Keil uVision project empty_model.uvproj, settings and files
target Target_1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: empty_model +hex
  link misc: REMOVEUNUSED
  group libraries
    ./libraries/: board.c board.h common.c common.h STC32_MDU32_V1.1.LIB STC32Gxx.h
  group seekfree_peripheral
    ./seekfree_peripheral/: SEEKFREE_IMU963RA.c SEEKFREE_IMU963RA.h
  group seekfree_libraries
    ./seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_eeprom.c zf_eeprom.h zf_exti.c zf_exti.h zf_fifo.c zf_fifo.h zf_function.c zf_function.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_mdu16.c zf_mdu16.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group user
    ./user/: main.c isr.c isr.h main.h motor.c motor.h encoder.c encoder.h pid.c pid.h filter.c filter.h
